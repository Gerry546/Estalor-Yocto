PACKAGECONFIG:append:reterminal = " networkd resolved"

RDEPENDS:${PN}:append:reterminal = " wpa-supplicant "